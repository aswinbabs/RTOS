# Keil uVision project first.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: first
  c flags: Optim=1
  c include: C:\Aswin(RTOS)\FreeRTOS\FreeRTOS\Source\include;C:\Aswin(RTOS)\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    C:/Aswin(RTOS)/FreeRTOS/FreeRTOS/Demo/ARM7_LPC2129_Keil_RVDS 1 (original 12Mhz)/: Startup.s
  group RTOS
    C:/Aswin(RTOS)/FreeRTOS/FreeRTOS/Source/: list.c queue.c tasks.c
    C:/Aswin(RTOS)/FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    C:/Aswin(RTOS)/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
